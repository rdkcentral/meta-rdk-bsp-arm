require ccsp_common_genericarm.inc
