SYSTEMD_SERVICE:${PN}:remove = "RdkInterDeviceManager.service"
