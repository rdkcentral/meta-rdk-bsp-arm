DEPENDS:append = " rdk-wifi-halif"
