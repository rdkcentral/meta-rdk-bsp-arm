# Minimum version with "link_stats_alarm_policy_cfg" defined
SRCREV_Unified-wifi-mesh_header = "6b672f3c6943407f063a5048e2ea37ef134de43e"
SRCREV_FORMAT = "Unified-wifi-mesh_header"