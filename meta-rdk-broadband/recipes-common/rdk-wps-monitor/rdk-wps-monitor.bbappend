FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-rdk-wps-monitor-handle-power-key-events-separately-t.patch"

