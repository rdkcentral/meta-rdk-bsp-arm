SRC_URI:append:kirkstone = "\
           file://0001-ecryptfs-patch-for-openssl-1.x.patch \
           "

