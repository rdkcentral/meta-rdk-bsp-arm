CFLAGS:append = " -Wno-error=maybe-uninitialized"
