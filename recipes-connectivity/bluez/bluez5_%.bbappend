# 2026-10-15 force removal after RDKBACCL-1926
SRC_URI:remove = "file://Bluetooth_service_dependency_broadband.patch"
