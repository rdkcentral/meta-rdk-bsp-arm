RCONFLICTS_${PN}:remove:broadband-dev = "dropbear"
RCONFLICTS_${PN}-sshd:remove:broadband-dev = "dropbear"

RCONFLICTS:${PN}:remove:bootbroadband = "dropbear"
RCONFLICTS:${PN}-sshd:remove:bootbroadband = "dropbear"

