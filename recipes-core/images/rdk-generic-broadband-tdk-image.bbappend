rdk-generic-broadband-image.bbappend