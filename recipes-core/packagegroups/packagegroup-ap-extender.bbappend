#components used in EasyMesh AP extender
RDEPENDS_packagegroup-ap-extender = "\
    ccsp-common-library \
    ccsp-common-startup \
    sysint-broadband \
    ccsp-one-wifi \
    rbus \
    ccsp-gwprovapp \
    ccsp-cr \
    ccsp-cr-ccsp \
    ccsp-psm \
    ccsp-psm-ccsp \
    unified-wifi-mesh \
    ieee1905-em \
    unified-wifi-mesh-personality-extender \
"
DEPENDS += " ccsp-common-library"
