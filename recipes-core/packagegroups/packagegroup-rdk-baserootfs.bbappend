RDEPENDS_packagegroup-rdk-baserootfs:append = "\
    e2fsprogs-resize2fs \
"
