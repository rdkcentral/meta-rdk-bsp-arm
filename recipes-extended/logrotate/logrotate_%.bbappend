FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI:append = " file://0001-meta-rdk-bsp-arm-only-logrotate-create-statefile-in-.patch"