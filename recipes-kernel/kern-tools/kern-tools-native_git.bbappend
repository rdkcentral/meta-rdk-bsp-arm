FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:kirkstone = " file://0001-tools-Kconfiglib-add-support-for-transitional-attrib.patch"

