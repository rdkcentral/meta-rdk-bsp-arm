# Disable Openvswitch launching on boot
SYSTEMD_SERVICE:${PN}-switch = ""
