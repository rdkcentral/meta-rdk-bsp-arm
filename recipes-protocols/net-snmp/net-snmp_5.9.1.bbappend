FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-Linux-6.7-compatibility-parsing-proc-net-snmp.patch"

